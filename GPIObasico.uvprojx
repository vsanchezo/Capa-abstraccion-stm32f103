# Keil uVision project GPIObasico.uvprojx, settings and files
target STM32f103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIObasico
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c
  group libs de usuario
    ./: capa_de_abstraccion_gpio.h capa_de_abstraccion_gpio.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
